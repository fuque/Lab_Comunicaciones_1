options:
  parameters:
    author: L1A_G6
    copyright: L1A_G6
    generate_options: qt_gui
    id: ModulacionPAM
    output_language: python
    title: ModulacionPAM
  states: {}

blocks:
- name: D1
  id: variable_qtgui_range
  parameters:
    rangeType: int
    start: '0'
    step: '1'
    stop: '100'
    value: '50'
  states: {}
- name: D2
  id: variable_qtgui_range
  parameters:
    rangeType: int
    start: '0'
    step: '1'
    stop: '100'
    value: '50'
  states: {}
- name: D3
  id: variable_qtgui_range
  parameters:
    rangeType: int
    start: '0'
    step: '1'
    stop: '100'
    value: '50'
  states: {}
- name: W
  id: variable_qtgui_range
  parameters:
    label: Ancho del pulso
    rangeType: int
    start: '0'
    step: '1'
    stop: '1000'
    value: '50'
  states: {}
- name: fm
  id: variable
  parameters:
    value: fs/10
  states: {}
- name: fs
  id: variable
  parameters:
    value: samp_rate/100
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 200e3
  states: {}
- name: ModuladorPAM_0
  id: ModuladorPAM
  parameters:
    D: W
    Fs: fs
    Samp_rate: samp_rate
  states: {}
- name: ModuladorPAM_0_0
  id: ModuladorPAM
  parameters:
    D: W
    Fs: fs
    Samp_rate: samp_rate
  states: {}
- name: ModuladorPAM_0_1
  id: ModuladorPAM
  parameters:
    D: W
    Fs: fs
    Samp_rate: samp_rate
  states: {}
- name: ModuladorPAM_0_2
  id: ModuladorPAM
  parameters:
    D: W
    Fs: fs
    Samp_rate: samp_rate
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: fm
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: fm
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SQR_WAVE
  states: {}
- name: analog_sig_source_x_0_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: fm
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_TRI_WAVE
  states: {}
- name: analog_sig_source_x_0_2
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: fm
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SAW_WAVE
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: D2
    type: float
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: D1
    type: float
  states: {}
- name: blocks_delay_0_1
  id: blocks_delay
  parameters:
    delay: D3
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    nconnections: '4'
    size: 1024*4
    srate: samp_rate
    type: float
  states: {}

connections:
- [ModuladorPAM_0, '0', blocks_delay_0_1, '0']
- [ModuladorPAM_0_0, '0', qtgui_time_sink_x_0, '0']
- [ModuladorPAM_0_1, '0', blocks_delay_0, '0']
- [ModuladorPAM_0_2, '0', blocks_delay_0_0, '0']
- [analog_sig_source_x_0, '0', ModuladorPAM_0_0, '0']
- [analog_sig_source_x_0_0, '0', ModuladorPAM_0_2, '0']
- [analog_sig_source_x_0_1, '0', ModuladorPAM_0_1, '0']
- [analog_sig_source_x_0_2, '0', ModuladorPAM_0, '0']
- [blocks_delay_0, '0', qtgui_time_sink_x_0, '2']
- [blocks_delay_0_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_delay_0_1, '0', qtgui_time_sink_x_0, '3']

metadata:
  file_format: 1
